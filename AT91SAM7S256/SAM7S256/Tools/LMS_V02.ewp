# IAR project LMS_V02.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: ..\Lib\dl4tptinl8n.h
  ICCARM.CCIncludePaths: ..\..\; ..\Include\
  ICCARM.CCDefines: PROTOTYPE_PCB_4; NEW_MENU
  XLINK.XclFile: at91SAM7S256_Remap.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  ICCARM.CCIncludePaths: $TOOLKIT_DIR$\INC\
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
configuration Binary Output (ARM, debug)
  as the first configuration, except:
  group (top)
    ../../Source/: c_button.c c_cmd.c c_comm.c c_display.c c_input.c c_ioctrl.c c_loader.c c_lowspeed.c c_output.c c_sound.c c_ui.c d_bt.c d_button.c d_display.c d_hispeed.c d_input.c d_ioctrl.c d_loader.c d_lowspeed.c d_output.c d_sound.c d_timer.c d_usb.c m_sched.c
    ../Include/: Cstartup.s79 Cstartup_SAM7.c
